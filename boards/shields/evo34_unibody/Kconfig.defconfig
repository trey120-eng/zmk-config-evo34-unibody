## boards/shields/evo34_unibody/Kconfig.defconfig
```kconfig
if SHIELD_EVO34_UNIBODY

# Name must be less than 16 characters long!
config ZMK_KEYBOARD_NAME
    default "Evo34-unibody"

endif
```
